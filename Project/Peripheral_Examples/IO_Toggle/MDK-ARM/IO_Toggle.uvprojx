# Keil uVision project IO_Toggle.uvprojx, settings and files
target IO_Toggle (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: IO_Toggle
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CMSIS\ST\STM32F0xx\Include;..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32F0-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../: main.c stm32f0xx_it.c system_stm32f0xx.c
  group STM32F0-Discovery
    C:/Users/win7/Documents/GitHub/Project1/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0_discovery.c
  group STM32F0xx_StdPeriph_Driver
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_gpio.c stm32f0xx_syscfg.c stm32f0xx_exti.c stm32f0xx_tim.c
    ./: neolib.c
  group MDK-ARM
    ../../../../Libraries/CMSIS/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
software components: CMSIS:CORE 5.1.1
